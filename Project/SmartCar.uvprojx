# Keil uVision project SmartCar.uvprojx, settings and files
target SmartCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Hardware;.\Core;.\StdPeriph\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Hardware
    ./Hardware/: motor.c encoder.c track.c iravoid.c ultrasonic.c bluetooth.c
  group CMSIS
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group StdPeriph
    ./StdPeriph/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_flash.c
software components: CMSIS:CORE 5.0.1
